File: circuits/AnalogCalculator/AnalogComputer/BufferFollower.kicad_sch (KiCad schematic)
At the start: 1 part, among them U7 LM324

Commit message: update examples
Parts:
- renumbered U7 to U12
